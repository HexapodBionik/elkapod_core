Commit message: #4 Fixed some problems with elkapod_motion package, elkapod_left_leg_description

File: elkapod_left_leg_description/urdf/left_leg.urdf (robot description, URDF)
Before this commit: robot elkapod_left_leg_description, 5 links, 4 joints
Joints:
- joint J1: axis 0 0 -1 -> 0 0 1
